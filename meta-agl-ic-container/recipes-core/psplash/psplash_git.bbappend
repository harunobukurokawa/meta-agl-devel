require psplash_agldemo.inc
